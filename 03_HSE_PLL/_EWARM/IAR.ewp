# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ..\; ..\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.cpp
  group _EWARM
    ./: startup_stm32f103xb.s stm32f103xb_flash.icf
  group CMSIS/Device
    ../CMSIS/Device/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group CMSIS/Include
    ../source/CMSIS/Include/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group user
    ../user/: RCC.cpp
