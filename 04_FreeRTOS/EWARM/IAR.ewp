# IAR project IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ..\source\CMSIS\Include; ..\source\CMSIS\Device\ST\STM32F1xx\Include; ..\source\FreeRTOS\; ..\source\FreeRTOS\include; ..\source\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR.hex
  ILINK.IlinkOutputFile: IAR.out
  ILINK.IlinkIcfFile: ..\source\CMSIS\Device\ST\STM32F1xx\Source\iar\linker\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/Device/ST/STM32F1xx/Include
    ../source/CMSIS/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group CMSIS/Device/ST/STM32F1xx/Source
    ../source/CMSIS/Device/ST/STM32F1xx/Source/: system_stm32f1xx.c
  group CMSIS/Device/ST/STM32F1xx/Source/iar
    ../source/CMSIS/Device/ST/STM32F1xx/Source/iar/: startup_stm32f103xb.s
  group CMSIS/Device/ST/STM32F1xx/Source/iar/linker
    ../source/CMSIS/Device/ST/STM32F1xx/Source/iar/linker/: stm32f103xb_flash.icf
  group CMSIS/Include
    ../source/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_gcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FreeRTOS
    ../source/FreeRTOS/: FreeRTOSConfig.h port.c portasm.s portmacro.h
  group FreeRTOS/inlcude
    ../source/FreeRTOS/include/: deprecated_definitions.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group FreeRTOS/src
    ../source/FreeRTOS/src/: heap_2.c list.c queue.c tasks.c timers.c
  group user
    ../source/: main.c
  group user/inc
    ../source/user/inc/: RCC.h
  group user/src
    ../source/user/src/: RCC.c
